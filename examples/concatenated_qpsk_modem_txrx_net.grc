options:
  parameters:
    generate_options: qt_gui
    id: concatenated_qpsk_modem_txrx_net
    output_language: python
  states: {}

blocks:
- name: R
  id: variable
  parameters:
    value: 1/2.
  states: {}
- name: arity
  id: variable
  parameters:
    value: 2**constel.bits_per_symbol()
  states: {}
- name: bps
  id: variable
  parameters:
    value: constel.bits_per_symbol()
  states: {}
- name: channel_gain
  id: variable_qtgui_entry
  parameters:
    label: Channel Gain (set to 0 to sim a disconnect)
    type: real
    value: '1'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    precision: '8'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: qpsk
  states: {}
- name: corr_sequence
  id: variable
  parameters:
    value: ((0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))
  states: {}
- name: corr_sequence_nodiff
  id: variable
  parameters:
    value: ((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j))
  states: {}
- name: decoder_variable
  id: variable_cc_decoder_def
  parameters:
    framebits: '1279'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[epy_tools.reverse_bits(0o171), epy_tools.reverse_bits(0o133)]'
    rate: int(1/R)
    state_end: '0'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:4,1
    label: Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: enc_idle_frame_len
  id: variable
  parameters:
    value: len(encoded_concat_idle_frame_nodiff)
  states: {}
- name: encoded_concat_idle_frame
  id: variable
  parameters:
    value: encoded_concat_idle_frame_raw
  states: {}
- name: encoded_concat_idle_frame_nodiff
  id: variable
  parameters:
    value: encoded_concat_idle_frame_nodiff_raw
  states: {}
- name: encoded_concat_idle_frame_nodiff_raw
  id: variable
  parameters:
    value: (206, 63, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 111, 93, 73, 194, 79, 242, 104, 107)
  states: {}
- name: encoded_concat_idle_frame_raw
  id: variable
  parameters:
    value: (31, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 15, 167, 58, 100, 15, 2, 76, 161)
  states: {}
- name: encoded_sync_word
  id: variable
  parameters:
    value: (246, 168, 195, 206, 128, 109)
  states: {}
- name: encoded_sync_word_nodiff
  id: variable
  parameters:
    value: (73, 194, 79, 242, 104, 107)
  states: {}
- name: encoder_variable
  id: variable_cc_encoder_def
  parameters:
    comment: |-
      Polynomials are often provided in octal.  
      The blocks generally take decimals, though.
      For example (171,133) => (121,91)

      Polynomials are read as if the shift register
      goes from right to left... e.g.,
      output <- [convolve 1001111] <- input
      corresponds to the polynomial
      0x4f=79d=0117.

      This is equivalent but "bit-reversed" from
      the left to right:
      input -> [convolve 1111001] -> output
      which woud be 0x79=121d=0171.
    framebits: '1279'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[epy_tools.reverse_bits(0o171), epy_tools.reverse_bits(0o133)]'
    rate: int(1/R)
    state_start: '0'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:5,1
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: fillframes_decoded
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_fillframes_decoded
    poll_rate: '10'
    value: '0'
  states: {}
- name: fillframes_sent
  id: variable_function_probe
  parameters:
    block_id: ccsds_insert_idle_frame
    function_name: num_fillframes_added
    poll_rate: '10'
    value: '0'
  states: {}
- name: frames_decoded
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_frames_decoded
    poll_rate: '10'
    value: '0'
  states: {}
- name: frames_received
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_frames_received
    poll_rate: '10'
    value: '0'
  states: {}
- name: frames_sent
  id: variable_function_probe
  parameters:
    block_id: ccsds_encoder
    function_name: num_frames
    poll_rate: '10'
    value: '0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:3,2
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.001'
  states: {}
- name: idle_frame_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:6,0,1,2
    label: Idle Frame Shift
    rangeType: int
    start: '-len(sync_word)*8'
    step: '2'
    stop: len(sync_word)*8
    value: 20+2-22
  states: {}
- name: mod_len
  id: variable
  parameters:
    value: len(modulated_idle_frame_trimmed_nodiff)
  states: {}
- name: modulated_idle_frame_trimmed
  id: variable
  parameters:
    value: '[modulated_preamble_untrimmed[i] for i in range(enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift)]'
  states: {}
- name: modulated_idle_frame_trimmed_nodiff
  id: variable
  parameters:
    value: '[modulated_preamble_untrimmed_nodiff[i] for i in range(enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift)]'
  states: {}
- name: modulated_preamble_untrimmed
  id: variable_modulate_vector
  parameters:
    data: encoded_sync_word+[0]*6+encoded_sync_word+[255]*6+encoded_sync_word+[0]*6
    mod: digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_rx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)
    taps: '[1]'
  states: {state: disabled}
- name: modulated_preamble_untrimmed
  id: variable_modulate_vector
  parameters:
    comment: |-
      Packed bytes get modulated.
      Samples come out.
      Since we're QPSK, you get
      8*sps/bps out.

      This modulator delays the
      center of the first symbol
      by 22 samples.
    data: list(encoded_concat_idle_frame)*3
    mod: digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)
    taps: '[1]'
  states: {}
- name: modulated_preamble_untrimmed_nodiff
  id: variable_modulate_vector
  parameters:
    data: list(encoded_concat_idle_frame_nodiff)*3
    mod: digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)
    taps: '[1]'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    value: '[modulated_preamble_untrimmed[i] for i in range(555, 775)]'
  states: {state: disabled}
- name: modulated_sync_word_0
  id: variable
  parameters:
    value: '[modulated_preamble_untrimmed[i] for i in range(555, 775)]'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:3,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1.5'
    value: '0.005'
  states: {}
- name: pad
  id: variable
  parameters:
    value: '[0]*223*5'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:5,2
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 2*pi/100.0*0+0.05
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@1:1,2,1,2
    label: Phase Offset
    start: '-pi'
    step: 2*pi/100.
    stop: pi
    value: pi/2.
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)
  states: {}
- name: rx_data_rate
  id: variable
  parameters:
    value: rx_user_data_rate/R
  states: {}
- name: rx_data_rate_sps
  id: variable
  parameters:
    value: rx_data_rate/bps
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: rx_data_rate_sps*sps_rx
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: tx_data_rate_sps*sps_tx
  states: {}
- name: sps_rx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_tx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: subframes_decoded
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_subframes_decoded
    poll_rate: '10'
    value: '0'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0x1a, 0xcf, 0xfc, 0x1d]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: gui@0:4,2
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: tx_data_rate
  id: variable
  parameters:
    value: tx_user_data_rate/R
  states: {}
- name: tx_data_rate_sps
  id: variable
  parameters:
    value: tx_data_rate/bps
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:0,0
    label: frames sent
    type: raw
    value: frames_sent
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:1,0
    label: frames received
    type: raw
    value: frames_received
  states: {}
- name: variable_qtgui_label_0_1_0
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:0,1
    label: frames decoded
    type: raw
    value: frames_decoded
  states: {}
- name: variable_qtgui_label_0_1_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:1,1
    label: subframes decoded
    type: raw
    value: subframes_decoded
  states: {}
- name: variable_qtgui_label_0_1_1
  id: variable_qtgui_label
  parameters:
    label: frames detected minus decoded
    type: raw
    value: frames_received-frames_decoded
  states: {}
- name: variable_qtgui_label_0_1_1_0
  id: variable_qtgui_label
  parameters:
    label: fill frames sent minus received
    type: raw
    value: fillframes_sent - fillframes_decoded
  states: {}
- name: variable_qtgui_label_0_1_1_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:3,0
    label: fill frames sent
    type: raw
    value: fillframes_sent
  states: {}
- name: variable_qtgui_label_0_1_1_0_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: gui@2:3,1
    label: fill frames received
    type: raw
    value: fillframes_decoded
  states: {}
- name: variable_qtgui_label_0_1_1_0_1
  id: variable_qtgui_label
  parameters:
    label: all frames sent - frames decoded
    type: raw
    value: frames_sent + fillframes_sent - frames_decoded
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    comment: This ought to simulate spectral inversion...
  states: {state: bypassed}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: bypassed}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: |-
      Delay with 0 seems to deadlock 
      in some situations.  Copy helped.
    enabled: 'True'
    showports: 'True'
    type: float
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_prefix + "/Downloads/blah.txt"
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dan/Downloads/shakespeare.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 1279*16*10
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: 1279*8*2+idle_frame_shift
    type: complex
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '10'
    msg: pmt.intern("TEST")
    std: '10'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: channel_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply a fixed phase offset.
    const: np.exp(1j*phase_offset)
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 3.14/160
  states: {state: bypassed}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate_rx*0.5)
    type: complex
  states: {state: bypassed}
- name: blocks_skiphead_1_0
  id: blocks_skiphead
  parameters:
    num_items: 1*0+(704+1)//2*sps_tx-(316+32)*sps_tx
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1115'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"phase_est"'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_tx
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_rx
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_rx
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: modulated_preamble_untrimmed_nodiff
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: modulated_idle_frame_trimmed_nodiff
  states: {state: disabled}
- name: ccsds_decapsulate_net_0
  id: ccsds_decapsulate_net
  parameters:
    disaggregate: 'False'
    mtu: '1115'
    pad_byte: '0x7E'
  states: {state: disabled}
- name: ccsds_decapsulate_net_0_0
  id: ccsds_decapsulate_net
  parameters:
    disaggregate: 'False'
    mtu: '1115'
    pad_byte: '0x7E'
  states: {}
- name: ccsds_decoder
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'True'
    descramble: 'True'
    dual_basis: 'True'
    n_deinterleave: '5'
    printing: 'False'
    rs_decode: 'True'
    threshold: '4'
    verbose: 'False'
  states: {}
- name: ccsds_diff_decoder_0
  id: ccsds_diff_decoder
  parameters: {}
  states: {state: bypassed}
- name: ccsds_diff_encoder_0
  id: ccsds_diff_encoder
  parameters: {}
  states: {state: bypassed}
- name: ccsds_encapsulate_net_0_0_0
  id: ccsds_encapsulate_net
  parameters:
    aggregate: 'False'
    mtu: '1115'
    pad_byte: '0x7E'
    timeout: '100'
  states: {}
- name: ccsds_encoder
  id: ccsds_ccsds_encoder
  parameters:
    asm_tail: 'True'
    dual_basis: 'True'
    idle: 'False'
    idle_block_time: '50'
    interleave: 'True'
    len_tag_key: '"packet_len"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'True'
    type: message
    verbose: 'False'
  states: {}
- name: ccsds_insert_idle_frame
  id: ccsds_insert_idle_frame
  parameters:
    modulated_vector: modulated_idle_frame_trimmed_nodiff
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {state: bypassed}
- name: dest_ip
  id: parameter
  parameters:
    label: Destination IP Address
    value: '"127.0.0.1"'
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    value: '52002'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps_tx
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    comment: |-
      Outputs 2 floats for every 
      1 symbol input for QPSK.
    constellation: constel
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(corr_sequence)-1
    sps: '1'
    symbols: corr_sequence_nodiff
    threshold: 0.985*0+0.985
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''''.join([bin(x)[2:].zfill(8) for x in sync_word])'
    tagname: syncword
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw*0.1*0
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 45*0+55+len(rrc_taps)//2//32*0
    rolloff: eb
    samps_per_sym: sps_rx
    type: cc
    w: 2*3.14/100.0*0+phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0*0+phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps_rx
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: int(samp_rate_tx)
    type: '0'
  states: {state: disabled}
- name: epy_tools
  id: epy_module
  parameters:
    source_code: "\ndef reverse_bits(x):\n    return int(bin(x)[2:][::-1], base=2)\n\n"
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decoder_variable
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encoder_variable
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    samp_delay: '15'
    taps: firdes.root_raised_cosine(1, 2, 1, 0.5, 31)
    type: ccc
  states: {state: disabled}
- name: file_prefix
  id: parameter
  parameters:
    label: File Prefix
    value: expanduser('~')
  states: {}
- name: gui
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: fft
    label1: const
    label2: stats
    num_tabs: '3'
  states: {}
- name: he2pi_file_zeropad_source_0
  id: he2pi_file_zeropad_source
  parameters:
    file: file_prefix + "/Downloads/shakespeare.txt"
    repeat: 'True'
    slp: '1000'
    type: byte
    vlen: '1'
    zeropad: int(samp_rate_tx)
  states: {state: disabled}
- name: he2pi_precisiontiming_pt_resampler_0
  id: he2pi_precisiontiming_pt_resampler
  parameters:
    desired_path_length: '32'
    input_sample_rate: int(samp_rate_tx)
    output_sample_rate: int(samp_rate_rx)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_home
  id: import
  parameters:
    imports: from os.path import expanduser
  states: {}
- name: import_pi
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: mtu
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1115'
  states: {}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: tun2
    istunflag: 'True'
    mtu: mtu-2
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: dest_ip
    header: '0'
    payloadsize: '1472'
    port: int(dest_port)
    send_eof: 'True'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: int(source_port)
    src_zeros: 'False'
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: gui@1:2,2
    name: ''
    size: '1024'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: gui@1:2,1
    name: ''
    size: '1024'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '1024'
    gui_hint: gui@0:1,1,1,2
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: '"Constellation Decoder Out"'
    size: '1024'
    srate: user_data_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: gui@0:2,1,1,2
    label1: TX Bits
    label2: CC Bits
    name: ''
    nconnections: '2'
    size: '500'
    srate: user_data_rate
    tr_chan: '1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 10232*2
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    label2: ''
    marker1: '0'
    marker2: '0'
    size: len(modulated_preamble_untrimmed)
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    marker1: '0'
    size: len(modulated_preamble_untrimmed)
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    label2: ''
    marker1: '0'
    marker2: '0'
    size: len(modulated_idle_frame_trimmed_nodiff)
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1279*16*10
    srate: '1'
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: '"Rx Phase"'
    label2: '"|Correlation|^2"'
    name: '"Correlation Outputs"'
    nconnections: '2'
    size: 1024*4
    srate: samp_rate_tx
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_start"'
    type: float
    ymax: '1000'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: '"Rx Phase"'
    name: '"Correlation Outputs"'
    size: len(modulated_idle_frame_trimmed_nodiff)//bps
    srate: samp_rate_tx
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_tag: '"corr_start"'
    type: float
    update_time: '0.05'
    ymax: '1000'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_3_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"First Packet"'
    size: 1279*2*8+idle_frame_shift
    srate: '1'
    type: complex
  states: {state: disabled}
- name: rx_user_data_rate
  id: parameter
  parameters:
    label: RX Data Rate
    short_id: r
    type: intx
    value: '250000'
  states: {}
- name: source_ip
  id: parameter
  parameters:
    label: Source IP Address
    value: '"127.0.0.1"'
  states: {}
- name: source_port
  id: parameter
  parameters:
    label: Source Port
    value: '52001'
  states: {}
- name: tun
  id: parameter
  parameters:
    label: TUN Name
    value: '"tun1"'
  states: {}
- name: tx_user_data_rate
  id: parameter
  parameters:
    label: TX Data Rate
    short_id: t
    type: intx
    value: '250000'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bits_out
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bits_in
  states: {state: disabled}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: tun_source
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bits_out
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: bits_in
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: tun_source
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://%s:%s" % (source_ip, source_port)'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: '"tcp://%s:%s" % (source_ip, source_port)'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: '"tcp://%s:%s" % (dest_ip, dest_port)'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_interleave_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_arg_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_skiphead_0, '0']
- [blocks_copy_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0, '0', blocks_copy_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_head_1, '0', qtgui_time_sink_x_3_0_0, '0']
- [blocks_interleave_0, '0', fft_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', network_udp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', zeromq_pub_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', qtgui_time_sink_x_2_0_0, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', qtgui_time_sink_x_2_0_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', he2pi_precisiontiming_pt_resampler_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0_0_0_1, '0']
- [blocks_repack_bits_bb_0, '0', ccsds_diff_decoder_0, '0']
- [blocks_rotator_cc_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_skiphead_0, '0', blocks_throttle_0, '0']
- [blocks_skiphead_1_0, '0', ccsds_insert_idle_frame, '0']
- [blocks_stream_to_tagged_stream_0, '0', ccsds_encoder, in]
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_1, '0', blocks_complex_to_arg_2, '0']
- [blocks_throttle_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_throttle_1_0, '0', qtgui_time_sink_x_1_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_1, '0', ccsds_diff_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0_0_1_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_1_0, '0']
- [ccsds_decapsulate_net_0, '0', pdu_pdu_to_tagged_stream_0, pdus]
- [ccsds_decapsulate_net_0_0, '0', network_tuntap_pdu_0, pdus]
- [ccsds_decoder, out, ccsds_decapsulate_net_0, '0']
- [ccsds_decoder, out, ccsds_decapsulate_net_0_0, '0']
- [ccsds_diff_decoder_0, '0', ccsds_decoder, '0']
- [ccsds_diff_decoder_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [ccsds_diff_encoder_0, '0', fec_extended_encoder_0, '0']
- [ccsds_encapsulate_net_0_0_0, '0', virtual_sink_0_1_0, '0']
- [ccsds_encoder, '0', blocks_unpack_k_bits_bb_0_0_1, '0']
- [ccsds_insert_idle_frame, '0', blocks_head_0, '0']
- [ccsds_insert_idle_frame, '0', channels_channel_model_0, '0']
- [ccsds_insert_idle_frame, '0', qtgui_time_sink_x_1, '0']
- [channels_channel_model_0, '0', blocks_rotator_cc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_interleave_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_head_1, '0']
- [digital_constellation_modulator_0, '0', blocks_skiphead_1_0, '0']
- [digital_constellation_modulator_0, '0', ccsds_insert_idle_frame, '0']
- [digital_constellation_soft_decoder_cf_0, '0', fec_extended_decoder_0, '0']
- [digital_corr_est_cc_0_0, '0', blocks_complex_to_arg_1, '0']
- [digital_corr_est_cc_0_0, '0', blocks_tag_debug_1, '0']
- [digital_corr_est_cc_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_corr_est_cc_0_0, '1', blocks_complex_to_mag_squared_0, '0']
- [digital_costas_loop_cc_0, '0', digital_corr_est_cc_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_1, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [fec_extended_decoder_0, '0', ccsds_diff_decoder_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_skiphead_1_0, '0']
- [he2pi_file_zeropad_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [he2pi_file_zeropad_source_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [he2pi_precisiontiming_pt_resampler_0, '0', blocks_multiply_const_vxx_1, '0']
- [network_tuntap_pdu_0, pdus, ccsds_encapsulate_net_0_0_0, '0']
- [network_udp_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0_0_1_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_0_1, '0', ccsds_encoder, in]
- [zeromq_req_source_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-201-g5dcccd7e
