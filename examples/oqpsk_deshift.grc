options:
  parameters:
    author: Dan CaJacob
    generate_options: hb
    id: oqpsk_deshift
    output_language: python
    title: OQPSK De-Shift
  states: {}

blocks:
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(sps/2.)
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(sps/2.)
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    value: '2'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_skiphead_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_copy_0, '0', blocks_interleave_0, '0']
- [blocks_deinterleave_0, '0', blocks_delay_0, '0']
- [blocks_deinterleave_0, '0', blocks_skiphead_0, '0']
- [blocks_deinterleave_0, '1', blocks_interleave_0, '1']
- [blocks_delay_0, '0', blocks_copy_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_interleave_0, '0', pad_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_float_to_complex_0, '0']
- [blocks_skiphead_0, '0', blocks_interleave_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-201-g5dcccd7e
