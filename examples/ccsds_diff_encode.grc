options:
  parameters:
    author: Dan CaJacob
    generate_options: hb
    id: ccsds_diff_encoder
    output_language: python
    title: CCSDS Differential Encoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: digital_diff_encoder_bb_0_0_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0_0_0_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_deinterleave_0, '0', digital_diff_encoder_bb_0_0_0, '0']
- [blocks_deinterleave_0, '1', digital_diff_encoder_bb_0_0_0_0, '0']
- [blocks_interleave_0, '0', pad_sink_0, '0']
- [digital_diff_encoder_bb_0_0_0, '0', blocks_interleave_0, '0']
- [digital_diff_encoder_bb_0_0_0_0, '0', blocks_interleave_0, '1']
- [pad_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-201-g5dcccd7e
