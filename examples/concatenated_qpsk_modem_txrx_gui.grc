options:
  parameters:
    generate_options: qt_gui
    id: concatenated_qpsk_modem_txrx_gui
    max_nouts: 1279*8*sps_tx
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: R
  id: variable
  parameters:
    value: 1/2.
  states: {}
- name: arity
  id: variable
  parameters:
    value: 2**constel.bits_per_symbol()
  states: {}
- name: bps
  id: variable
  parameters:
    value: constel.bits_per_symbol()
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    precision: '8'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: qpsk
  states: {}
- name: corr_sequence
  id: variable
  parameters:
    value: ((0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))
  states: {}
- name: corr_sequence_0
  id: variable
  parameters:
    value: ((0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))
  states: {}
- name: corr_sequence_nodiff
  id: variable
  parameters:
    value: ((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j))
  states: {}
- name: corr_sequence_nodiff_0
  id: variable
  parameters:
    value: ((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j))
  states: {}
- name: decoder_variable
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[epy_tools.reverse_bits(0o171), epy_tools.reverse_bits(0o133)]'
    rate: int(1/R)
    state_end: '0'
    state_start: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: 0.7/2.
  states: {}
- name: enc_idle_frame_len
  id: variable
  parameters:
    value: len(encoded_concat_idle_frame_nodiff)
  states: {}
- name: encoded_concat_idle_frame
  id: variable
  parameters:
    value: encoded_concat_idle_frame_raw
  states: {}
- name: encoded_concat_idle_frame_nodiff
  id: variable
  parameters:
    value: encoded_concat_idle_frame_nodiff_raw
  states: {}
- name: encoded_concat_idle_frame_nodiff_raw
  id: variable
  parameters:
    value: (206, 63, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 111, 93, 73, 194, 79, 242, 104, 107)
  states: {}
- name: encoded_concat_idle_frame_raw
  id: variable
  parameters:
    value: (31, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 216, 195, 47, 110, 243, 228, 181, 79, 29, 152, 28, 218, 254, 27, 236, 65, 157, 23, 81, 250, 82, 133, 132, 198, 36, 229, 247, 173, 220, 138, 70, 171, 168, 215, 1, 66, 226, 193, 18, 90, 113, 86, 204, 237, 3, 127, 214, 67, 160, 35, 211, 72, 43, 39, 154, 33, 238, 124, 169, 149, 227, 131, 240, 155, 99, 12, 189, 187, 207, 146, 213, 60, 118, 96, 115, 107, 248, 111, 177, 6, 116, 93, 71, 233, 74, 22, 19, 24, 147, 151, 222, 183, 114, 41, 26, 174, 163, 92, 5, 11, 139, 4, 73, 105, 197, 91, 51, 180, 13, 255, 89, 14, 128, 143, 77, 32, 172, 158, 104, 135, 185, 242, 166, 87, 142, 15, 194, 109, 140, 50, 246, 239, 62, 75, 84, 241, 217, 129, 205, 175, 225, 190, 196, 25, 209, 117, 31, 165, 40, 88, 76, 98, 78, 95, 122, 221, 200, 164, 106, 186, 141, 112, 20, 46, 44, 17, 37, 167, 21, 108, 206, 208, 55, 253, 100, 58, 2, 61, 52, 130, 178, 121, 162, 30, 231, 202, 153, 94, 56, 63, 9, 182, 48, 203, 219, 188, 249, 45, 83, 199, 102, 7, 54, 191, 134, 251, 16, 103, 69, 212, 126, 148, 161, 97, 49, 137, 57, 125, 235, 119, 34, 145, 170, 234, 53, 192, 80, 184, 176, 68, 150, 156, 85, 179, 59, 64, 223, 245, 144, 232, 8, 244, 210, 10, 201, 230, 136, 123, 159, 42, 101, 120, 224, 252, 38, 15, 167, 58, 100, 15, 2, 76, 161)
  states: {}
- name: encoder_variable
  id: variable_cc_encoder_def
  parameters:
    comment: |-
      Polynomials are often provided in octal.  
      The blocks generally take decimals, though.
      For example (171,133) => (121,91)
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[epy_tools.reverse_bits(0o171), epy_tools.reverse_bits(0o133)]'
    rate: int(1/R)
    state_start: '0'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: 1279*2
  states: {}
- name: modulated_idle_frame_trimmed
  id: variable
  parameters:
    comment: |-
      Skip the first modulated fill 
      frame, which is mangled by 
      filter memory.
    value: '[modulated_preamble_untrimmed[i] for i in range(enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift)]'
  states: {}
- name: modulated_idle_frame_trimmed_nodiff
  id: variable
  parameters:
    comment: |-
      Skip the first modulated fill 
      frame, which is mangled by 
      filter memory.
    value: '[modulated_preamble_untrimmed_nodiff[i] for i in range(enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx//bps*8+idle_frame_shift)]'
  states: {}
- name: modulated_preamble_untrimmed
  id: variable_modulate_vector
  parameters:
    comment: |-
      Packed bytes get modulated.
      Samples come out.
      Since we're QPSK, you get
      8*sps/bps out.

      This modulator delays the
      center of the first symbol
      by 22 samples.
    data: list(encoded_concat_idle_frame)*3
    mod: digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)
    taps: '[1]'
  states: {}
- name: modulated_preamble_untrimmed_nodiff
  id: variable_modulate_vector
  parameters:
    data: list(encoded_concat_idle_frame_nodiff)*3
    mod: digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pad
  id: variable
  parameters:
    value: '[0]*223*5'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)
  states: {}
- name: rx_data_rate
  id: variable
  parameters:
    value: rx_user_data_rate/R
  states: {}
- name: rx_data_rate_sps
  id: variable
  parameters:
    value: rx_data_rate/bps
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: rx_data_rate_sps*sps_rx
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: tx_data_rate_sps*sps_tx
  states: {}
- name: sps_rx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_tx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_data_rate
  id: variable
  parameters:
    value: tx_user_data_rate/R
  states: {}
- name: tx_data_rate_sps
  id: variable
  parameters:
    value: tx_data_rate/bps
  states: {}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Use for low SNR.  Not good when SNR is high.
    const: '50'
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/pi
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: ccsds_decapsulate_net_0
  id: ccsds_decapsulate_net
  parameters:
    disaggregate: 'False'
    mtu: '1115'
    pad_byte: '0x7E'
  states: {}
- name: ccsds_decoder
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'True'
    descramble: 'True'
    dual_basis: 'True'
    n_deinterleave: '5'
    printing: 'False'
    rs_decode: 'True'
    threshold: '4'
    verbose: 'False'
  states: {}
- name: ccsds_diff_decoder_0
  id: ccsds_diff_decoder
  parameters: {}
  states: {state: bypassed}
- name: ccsds_diff_encoder_0
  id: ccsds_diff_encoder
  parameters: {}
  states: {state: bypassed}
- name: ccsds_encapsulate_net_0
  id: ccsds_encapsulate_net
  parameters:
    aggregate: 'False'
    mtu: '1115'
    pad_byte: '0x7E'
    timeout: '100'
  states: {}
- name: ccsds_encoder
  id: ccsds_ccsds_encoder
  parameters:
    asm_tail: 'True'
    dual_basis: 'True'
    idle: 'False'
    idle_block_time: '50'
    interleave: 'True'
    len_tag_key: '""'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'True'
    type: message
    verbose: 'False'
  states: {}
- name: ccsds_insert_idle_frame_0
  id: ccsds_insert_idle_frame
  parameters:
    modulated_vector: modulated_idle_frame_trimmed_nodiff
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps_tx
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
  states: {}
- name: digital_corr_est_cc_0_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(corr_sequence)-1
    sps: '1'
    symbols: corr_sequence_nodiff
    threshold: '0.985'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    use_snr: 'True'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Resolves 90 deg ambiguity.  
      Applies phase offset recovered 
      by corr est block.  Don't try 
      doing this before PFB CS
    order: arity
    w: phase_bw*0
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: eb
    samps_per_sym: sps_rx
    type: cc
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps_rx
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_tools
  id: epy_module
  parameters:
    source_code: "\ndef reverse_bits(x):\n    return int(bin(x)[2:][::-1], base=2)\n\n"
  states: {}
- name: eq_gain
  id: parameter
  parameters:
    label: Equalizer Rate
    type: eng_float
    value: '0.01'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decoder_variable
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encoder_variable
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: file_prefix
  id: parameter
  parameters:
    label: File Prefix
    value: expanduser('~')
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '40'
  states: {}
- name: idle_block_time
  id: parameter
  parameters:
    label: Idle Block Time (ms)
    type: eng_float
    value: '50'
  states: {}
- name: idle_frame_shift
  id: parameter
  parameters:
    label: Idle Frame Shift
    type: intx
    value: 22*0
  states: {}
- name: import_home
  id: import
  parameters:
    imports: from os.path import expanduser
  states: {}
- name: import_pi
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: mtu
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1115'
  states: {}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: tun
    istunflag: 'True'
    mtu: mtu-2
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Import from asm_post_costas.grc
    note: Corr Sequence
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: Import from idle_frame_encode.grc
    note: Idle Frame
  states: {}
- name: phase_bw
  id: parameter
  parameters:
    label: Phase Bandwidth
    type: eng_float
    value: 6.28/100.0*0+0.05
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rx
    fc: rx_freq
    fftsize: '1024'
    label1: Received
    label2: Post FLL BE
    nconnections: '2'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_tx
    fc: tx_freq
    fftsize: '1024'
    label1: Transmitted
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '"Rx Phase"'
    label2: '"|Correlation|^2"'
    name: '"Correlation Outputs"'
    nconnections: '2'
    size: 1024*4
    srate: samp_rate_tx
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_start"'
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: RX Frequency
    type: eng_float
    value: 415e6
  states: {}
- name: rx_user_data_rate
  id: parameter
  parameters:
    label: RX Data Rate
    short_id: r
    type: intx
    value: '250000'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '0.5'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0.999'
  states: {}
- name: tun
  id: parameter
  parameters:
    label: TUN Name
    value: '"tun1"'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: TX Frequency
    type: eng_float
    value: 400e6
  states: {}
- name: tx_user_data_rate
  id: parameter
  parameters:
    label: TX Data Rate
    short_id: t
    type: intx
    value: '250000'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_addr: type=b200
    dev_args: send_frame_size=512,num_send_frames=256,recv_frame_size=512,num_recv_frames=256
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate_tx
    stream_args: peak=0.7
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq
    clock_rate: '0.0'
    dev_addr: type=b200
    dev_args: send_frame_size=512,num_send_frames=256,recv_frame_size=512,num_recv_frames=256
    gain0: gain
    samp_rate: samp_rate_rx
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tun_source
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tun_sink
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tun_source
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tun_sink
  states: {}

connections:
- [blocks_complex_to_arg_1_0, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_1_0_0_0, '0', qtgui_time_sink_x_2_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', qtgui_time_sink_x_2_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tag_gate_0, '0', digital_corr_est_cc_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_1, '0', ccsds_diff_encoder_0, '0']
- [ccsds_decapsulate_net_0, '0', network_tuntap_pdu_0, pdus]
- [ccsds_decoder, out, virtual_sink_0_0, '0']
- [ccsds_diff_decoder_0, '0', ccsds_decoder, '0']
- [ccsds_diff_encoder_0, '0', fec_extended_encoder_0, '0']
- [ccsds_encapsulate_net_0, '0', virtual_sink_0, '0']
- [ccsds_encoder, '0', blocks_unpack_k_bits_bb_0_0_1, '0']
- [ccsds_insert_idle_frame_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ccsds_insert_idle_frame_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_constellation_modulator_0, '0', ccsds_insert_idle_frame_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', fec_extended_decoder_0, '0']
- [digital_corr_est_cc_0_0_0, '0', blocks_complex_to_arg_1_0, '0']
- [digital_corr_est_cc_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_corr_est_cc_0_0_0, '1', blocks_complex_to_mag_squared_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_tag_gate_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [fec_extended_decoder_0, '0', ccsds_diff_decoder_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [network_tuntap_pdu_0, pdus, ccsds_encapsulate_net_0, '0']
- [satellites_rms_agc_0, '0', digital_fll_band_edge_cc_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', satellites_rms_agc_0, '0']
- [virtual_source_0, '0', ccsds_encoder, in]
- [virtual_source_0_0, '0', ccsds_decapsulate_net_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-201-g5dcccd7e
